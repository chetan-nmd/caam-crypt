inherit externalsrc
EXTERNALSRC = "/home/ubuntu/Desktop/crypto_af_alg-lf-6.1.36_2.1.0"
EXTERNALSRC_BUILD = "/home/ubuntu/Desktop/crypto_af_alg-lf-6.1.36_2.1.0"
